# Keil uVision project Project.uvprojx, settings and files
target STM32F103RC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM32F103_CUSTOM, CR95HF, SYS_DEBUG
  c misc: --diag_suppress 236
  c include: ..\inc;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Core\CM3;..\..\Utilities\FreeRTOSv10.0.1\include;..\..\Utilities\FreeRTOSv10.0.1\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source
    ../src/: buttons.c eeprom.c hw_config.c main.c stm32f10x_it.c uart_command.c Valve.c zwave.c
  group Configs
    ../inc/: FreeRTOSConfig.h
  group STM32F10x_StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ../../Utilities/FreeRTOSv10.0.1/: croutine.c list.c queue.c tasks.c event_groups.c stream_buffer.c timers.c
    ../../Utilities/FreeRTOSv10.0.1/portable/RVDS/ARM_CM3/: port.c
    ../../Utilities/FreeRTOSv10.0.1/portable/MemMang/: heap_2.c heap_1.c
  group RVMDK
    ../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/Core/CM3/: system_stm32f10x.c core_cm3.c
target STM32F107RC (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F107RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210C-EVAL
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c misc: --diag_suppress 236
  c include: ..\inc;..\..\Utilities\STM32_EVAL;..\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\Libraries\CMSIS\Core\CM3;..\..\Utilities\lwip_v1.3.2\port\STM32F4x7;..\..\Utilities\lwip_v1.3.2\src\include;..\..\Utilities\lwip_v1.3.2\src\include\ipv4;..\..\Utilities\lwip_v1.3.2\src\include\lwip;..\..\Utilities\efsl\include;..\..\Utilities\efsl\include\interface;..\..\Utilities\FreeRTOS_v6.1.0\include;..\..\Utilities\FreeRTOS_v6.1.0\portable\MDK-ARM\ARM_CM3;..\..\Utilities\lwip_v1.3.2\src\include\netif;..\..\Utilities\lwip_v1.3.2\port\STM32F4x7\FreeRTOS
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
